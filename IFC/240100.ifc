Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Jonas\Documents\Cadfocus\Ostnor\2012\CAD-objekt_2012-09-28\CADFOCUS\240100\AutoCAD Architecture\240100.ifc
Time: 2012-10-16T13:18:05
Author: - -
Organization: Mora Armatur, Ostnor AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 240100
LongName: 240100
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 240100
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 240100, BUILDINGELEMENTPROXY(1)
In: 240100
Description: Mora Cera T4 Mixer For Bath 150 c/c chrome
